SRC_URI_remove = "\
	git://github.com/google/protobuf.git;branch=master \
"

SRC_URI_append = "\
	git://github.com/google/protobuf.git;branch=main \
"
